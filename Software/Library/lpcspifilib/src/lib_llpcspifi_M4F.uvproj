# Keil uVision project lib_llpcspifi_M4F.uvproj, settings and files
target lib_lpcspifi_M4F (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: lib_lpcspifi_M4F (library)
  AfterMake: cmd /c copy !L ..\lib\keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: .\;..\..\CMSIS\CMSIS\Include;..\..\lpc_core\lpc_chip\chip_common;..\..\lpc_core\lpc_chip\chip_18xx_43xx;..\..\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\inc
  group src
    ./: spifilib_dev_common.c spifilib_dev_spansion_s25fl1.c spifilib_dev_macronix_mx25l.c spifilib_dev_spansion_s25flp.c
