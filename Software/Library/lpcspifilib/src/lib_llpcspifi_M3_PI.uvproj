# Keil uVision project lib_llpcspifi_M3_PI.uvproj, settings and files
target lib_lpcspifi_M3_PI (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: lib_lpcspifi_M3_PI (library)
  AfterMake: cmd /c copy !L ..\lib\keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c misc: --lower_ropi
  c include: .\;..\..\CMSIS\CMSIS\Include;..\..\lpc_core\lpc_chip\chip_common;..\..\lpc_core\lpc_chip\chip_18xx_43xx;..\..\lpc_core\lpc_chip\chip_18xx_43xx\config_18xx;..\inc
  group src
    ./: spifilib_dev_common.c spifilib_dev_spansion_s25fl1.c spifilib_dev_spansion_s25flp.c spifilib_dev_macronix_mx25l.c
