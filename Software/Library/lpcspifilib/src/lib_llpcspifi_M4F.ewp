# IAR project lib_llpcspifi_M4F.ewp, settings and files
configuration lib_lpcspifi_M4F (ARM)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CORE_M3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\lpc_core\lpc_chip\chip_common; ..\..\CMSIS\CMSIS\Include; ..\inc; ..\..\lpc_core\lpc_chip\chip_18xx_43xx\config_18xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd /c copy iar_output\lib_lpcspifi_M4F\Exe\lib_llpcspifi_M4F.a ..\lib\IAR
  ILINK.IlinkOutputFile: lib_llpcspifi_18xx.out
  group src
    ./: spifilib_dev_common.c spifilib_dev_macronix_mx25l.c spifilib_dev_spansion_s25fl1.c spifilib_dev_spansion_s25flp.c
